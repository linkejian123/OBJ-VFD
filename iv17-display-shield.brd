# Repository linkejian123/OBJ-VFD

File README.md:

View this project on [CADLAB.io](https://cadlab.io/node/819). 

# OBJ-VFD

### Overview
This is design of IV-17 VFD tube clock inspired by Adafruit. However, the design is simpler, especially at the lack of microcontroller managed boost buck converter.

### Current final files are the crystalis board files. 

### Authors
Kejian Lin
Yuxuan Zhao

### Currently only have PCB files and package concept. Coding in progress

## EAGLE design iv17-display-shield.brd

Parts:
C1: 470uf; E5-10,5
C7, C8: CPOL-USE5-13; E5-13
C11, C12, C21, C22, C31, C32, C41, C42, C51, C52, C61, C62: 100nf; C1206
CL1, CL2, CL3, CL4, CL5, CL6: 100nf; C1206
IC1, IC2: MURATA 5V; TO220V
L1, L2, L3, L4, L5, L6: WS2812B
LED2: 5vfil; LED3MM
LED3: 5v1; LED3MM
R3: R-US_0309/12; 0309/12
R4, R5: R-US_M1206; M1206
SHIFT1, SHIFT2, SHIFT3, SHIFT4, SHIFT5, SHIFT6: MAX6921; SOIC-28W
TUBE1, TUBE2, TUBE3, TUBE4, TUBE5, TUBE6: IV17; NIXIE-22
WIRE: wire; 0309/12
X1: 24vdc; 233-102

Connections:
5VDC: C11.1, C21.1, C31.1, C41.1, C51.1, C61.1, CL1.1, CL2.1, CL3.1, CL4.1, CL5.1, CL6.1, L1.1-VDD (VDD), L2.1-VDD (VDD), L3.1-VDD (VDD), L4.1-VDD (VDD), L5.1-VDD (VDD), L6.1-VDD (VDD), SHIFT1.28 (VCC), SHIFT2.28 (VCC), SHIFT3.28 (VCC), SHIFT4.28 (VCC), SHIFT5.28 (VCC), SHIFT6.28 (VCC)
24VDC: C1.+, C12.2, C22.2, C32.2, C42.2, C52.2, C62.2, IC1.1 (VI), IC2.1 (VI), SHIFT1.1 (VBB), SHIFT2.1 (VBB), SHIFT3.1 (VBB), SHIFT4.1 (VBB), SHIFT5.1 (VBB), SHIFT6.1 (VBB), TUBE1.12 (12GRID), TUBE2.12 (12GRID), TUBE3.12 (12GRID), TUBE4.12 (12GRID), TUBE5.12 (12GRID), TUBE6.12 (12GRID), X1.B1 (B-1)
AGND: C1.-, C7.-, C8.-, C11.2, C12.1, C21.2, C22.1, C31.2, C32.1, C41.2, C42.1, C51.2, C52.1, C61.2, C62.1, CL1.2, CL2.2, CL3.2, CL4.2, CL5.2, CL6.2, IC1.2 (GND), IC2.2 (GND), L1.3-GND (GND), L2.3-GND (GND), L3.3-GND (GND), L4.3-GND (GND), L5.3-GND (GND), L6.3-GND (GND), LED2.K (C), LED3.K (C), R3.1, SHIFT1.14 (GND), SHIFT2.14 (GND), SHIFT3.14 (GND), SHIFT4.14 (GND), SHIFT5.14 (GND), SHIFT6.14 (GND), WIRE.2, X1.B2 (B-2)
BLANK: SHIFT1.13 (BLANK), SHIFT2.13 (BLANK), SHIFT3.13 (BLANK), SHIFT4.13 (BLANK), SHIFT5.13 (BLANK), SHIFT6.13 (BLANK); also elsewhere on the board
CLK: SHIFT1.15 (CLK), SHIFT2.15 (CLK), SHIFT3.15 (CLK), SHIFT4.15 (CLK), SHIFT5.15 (CLK), SHIFT6.15 (CLK); also elsewhere on the board
DATA: SHIFT1.27 (DIN); also elsewhere on the board
GND: WIRE.1; also elsewhere on the board
LED-DATA: L1.4-DIN (DIN); also elsewhere on the board
LOAD: SHIFT1.16 (LOAD), SHIFT2.16 (LOAD), SHIFT3.16 (LOAD), SHIFT4.16 (LOAD), SHIFT5.16 (LOAD), SHIFT6.16 (LOAD); also elsewhere on the board
unnamed: SHIFT1.2 (DOUT), SHIFT2.27 (DIN)
unnamed: TUBE5.11 (11FIL-), TUBE6.1 (1FIL+)
unnamed: SHIFT2.2 (DOUT), SHIFT3.27 (DIN)
unnamed: SHIFT3.2 (DOUT), SHIFT4.27 (DIN)
unnamed: SHIFT4.2 (DOUT), SHIFT5.27 (DIN)
unnamed: SHIFT5.2 (DOUT), SHIFT6.27 (DIN)
unnamed: R3.2, TUBE2.11 (11FIL-), TUBE4.11 (11FIL-), TUBE6.11 (11FIL-)
unnamed: LED2.A, R5.1
unnamed: LED3.A, R4.1
unnamed: SHIFT5.26 (OUT0), TUBE5.2
unnamed: SHIFT5.25 (OUT1), TUBE5.3
unnamed: SHIFT5.24 (OUT2), TUBE5.4
unnamed: SHIFT5.23 (OUT3), TUBE5.5
unnamed: SHIFT5.22 (OUT4), TUBE5.6
unnamed: SHIFT5.21 (OUT5), TUBE5.7
unnamed: SHIFT5.20 (OUT6), TUBE5.8
unnamed: SHIFT5.19 (OUT7), TUBE5.9
unnamed: SHIFT5.18 (OUT8), TUBE5.10
unnamed: SHIFT5.17 (OUT9), TUBE5.13
unnamed: SHIFT5.12 (OUT10), TUBE5.14
unnamed: SHIFT5.11 (OUT11), TUBE5.15
unnamed: SHIFT5.10 (OUT12), TUBE5.16
unnamed: SHIFT5.9 (OUT13), TUBE5.17
unnamed: SHIFT5.8 (OUT14), TUBE5.18
unnamed: SHIFT5.7 (OUT15), TUBE5.19
unnamed: SHIFT5.6 (OUT16), TUBE5.20
unnamed: SHIFT5.5 (OUT17), TUBE5.21
unnamed: SHIFT6.26 (OUT0), TUBE6.2
unnamed: SHIFT6.25 (OUT1), TUBE6.3
unnamed: SHIFT6.24 (OUT2), TUBE6.4
unnamed: SHIFT6.23 (OUT3), TUBE6.5
unnamed: SHIFT6.22 (OUT4), TUBE6.6
unnamed: SHIFT6.21 (OUT5), TUBE6.7
unnamed: SHIFT6.20 (OUT6), TUBE6.8
unnamed: SHIFT6.19 (OUT7), TUBE6.9
unnamed: SHIFT6.18 (OUT8), TUBE6.10
unnamed: SHIFT6.17 (OUT9), TUBE6.13
unnamed: SHIFT6.12 (OUT10), TUBE6.14
unnamed: SHIFT6.11 (OUT11), TUBE6.15
unnamed: SHIFT6.10 (OUT12), TUBE6.16
unnamed: SHIFT6.9 (OUT13), TUBE6.17
unnamed: SHIFT6.8 (OUT14), TUBE6.18
unnamed: SHIFT6.7 (OUT15), TUBE6.19
unnamed: SHIFT6.6 (OUT16), TUBE6.20
unnamed: SHIFT6.5 (OUT17), TUBE6.21
unnamed: SHIFT3.26 (OUT0), TUBE3.2
unnamed: SHIFT3.25 (OUT1), TUBE3.3
unnamed: SHIFT3.24 (OUT2), TUBE3.4
unnamed: SHIFT3.23 (OUT3), TUBE3.5
unnamed: SHIFT3.22 (OUT4), TUBE3.6
unnamed: SHIFT3.21 (OUT5), TUBE3.7
unnamed: SHIFT3.20 (OUT6), TUBE3.8
unnamed: SHIFT3.19 (OUT7), TUBE3.9
unnamed: SHIFT3.18 (OUT8), TUBE3.10
unnamed: SHIFT3.17 (OUT9), TUBE3.13
unnamed: SHIFT3.12 (OUT10), TUBE3.14
unnamed: SHIFT3.11 (OUT11), TUBE3.15
unnamed: SHIFT3.10 (OUT12), TUBE3.16
unnamed: SHIFT3.9 (OUT13), TUBE3.17
unnamed: SHIFT3.8 (OUT14), TUBE3.18
unnamed: SHIFT3.7 (OUT15), TUBE3.19
unnamed: SHIFT3.6 (OUT16), TUBE3.20
unnamed: SHIFT3.5 (OUT17), TUBE3.21
unnamed: SHIFT4.26 (OUT0), TUBE4.2
unnamed: SHIFT4.25 (OUT1), TUBE4.3
unnamed: SHIFT4.24 (OUT2), TUBE4.4
unnamed: SHIFT4.23 (OUT3), TUBE4.5
unnamed: SHIFT4.22 (OUT4), TUBE4.6
unnamed: SHIFT4.21 (OUT5), TUBE4.7
unnamed: SHIFT4.20 (OUT6), TUBE4.8
unnamed: SHIFT4.19 (OUT7), TUBE4.9
unnamed: SHIFT4.18 (OUT8), TUBE4.10
unnamed: SHIFT4.17 (OUT9), TUBE4.13
unnamed: SHIFT4.12 (OUT10), TUBE4.14
unnamed: SHIFT4.11 (OUT11), TUBE4.15
unnamed: SHIFT4.10 (OUT12), TUBE4.16
unnamed: SHIFT4.9 (OUT13), TUBE4.17
unnamed: SHIFT4.8 (OUT14), TUBE4.18
unnamed: SHIFT4.7 (OUT15), TUBE4.19
unnamed: L1.2-DOUT (DOUT), L2.4-DIN (DIN)
unnamed: SHIFT4.6 (OUT16), TUBE4.20
unnamed: SHIFT4.5 (OUT17), TUBE4.21
unnamed: SHIFT1.26 (OUT0), TUBE1.2
unnamed: SHIFT1.25 (OUT1), TUBE1.3
unnamed: SHIFT1.24 (OUT2), TUBE1.4
unnamed: SHIFT1.23 (OUT3), TUBE1.5
unnamed: SHIFT1.22 (OUT4), TUBE1.6
unnamed: SHIFT1.21 (OUT5), TUBE1.7
unnamed: SHIFT1.20 (OUT6), TUBE1.8
unnamed: SHIFT1.19 (OUT7), TUBE1.9
unnamed: SHIFT1.18 (OUT8), TUBE1.10
unnamed: SHIFT1.17 (OUT9), TUBE1.13
unnamed: SHIFT1.12 (OUT10), TUBE1.14
unnamed: SHIFT1.11 (OUT11), TUBE1.15
unnamed: SHIFT1.10 (OUT12), TUBE1.16
unnamed: SHIFT1.9 (OUT13), TUBE1.17
unnamed: SHIFT1.8 (OUT14), TUBE1.18
unnamed: SHIFT1.7 (OUT15), TUBE1.19
unnamed: SHIFT1.6 (OUT16), TUBE1.20
unnamed: L2.2-DOUT (DOUT), L3.4-DIN (DIN)
unnamed: L3.2-DOUT (DOUT), L4.4-DIN (DIN)
unnamed: SHIFT1.5 (OUT17), TUBE1.21
unnamed: SHIFT2.26 (OUT0), TUBE2.2
unnamed: SHIFT2.25 (OUT1), TUBE2.3
unnamed: SHIFT2.24 (OUT2), TUBE2.4
unnamed: SHIFT2.23 (OUT3), TUBE2.5
unnamed: SHIFT2.22 (OUT4), TUBE2.6
unnamed: SHIFT2.21 (OUT5), TUBE2.7
unnamed: SHIFT2.20 (OUT6), TUBE2.8
unnamed: SHIFT2.19 (OUT7), TUBE2.9
unnamed: SHIFT2.18 (OUT8), TUBE2.10
unnamed: SHIFT2.17 (OUT9), TUBE2.13
unnamed: SHIFT2.12 (OUT10), TUBE2.14
unnamed: SHIFT2.11 (OUT11), TUBE2.15
unnamed: SHIFT2.10 (OUT12), TUBE2.16
unnamed: SHIFT2.9 (OUT13), TUBE2.17
unnamed: SHIFT2.8 (OUT14), TUBE2.18
unnamed: SHIFT2.7 (OUT15), TUBE2.19
unnamed: SHIFT2.6 (OUT16), TUBE2.20
unnamed: SHIFT2.5 (OUT17), TUBE2.21
unnamed: L4.2-DOUT (DOUT), L5.4-DIN (DIN)
unnamed: L5.2-DOUT (DOUT), L6.4-DIN (DIN)
unnamed: TUBE1.11 (11FIL-), TUBE2.1 (1FIL+)
unnamed: TUBE3.11 (11FIL-), TUBE4.1 (1FIL+)
VCC: C8.+, IC1.3 (VO), R4.2; also elsewhere on the board
VFIL: C7.+, IC2.3 (VO), R5.2, TUBE1.1 (1FIL+), TUBE3.1 (1FIL+), TUBE5.1 (1FIL+)

Parts:
C2, C3, C4: 0.1uF; C1206
C5, C6: 6pF; C1206
JPA: M08; 1X08_ROUND
JPB: M08; 1X08_ROUND
JPD: M08; 1X08_ROUND
LED1: heart; LED3MM
Q1: XTAL/S; QS
R1: 4.7K; 0309/12
R2: R-US_M1206; M1206
S0, S1, S2: 40-XX; B3F-40XX
S3: 10-XX; B3F-10XX
U1: ATMEGA328P_PDIP; DIL28-3

Connections:
BLANK: U1.26 (PC3(ADC3)); also elsewhere on the board
CLK: U1.24 (PC1(ADC1)); also elsewhere on the board
DATA: U1.23 (PC0(ADC0)); also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, JPA.3, JPA.8, JPB.8, JPD.8, LED1.K (C), S0.1 (S), S0.2 (S1), S1.1 (S), S1.2 (S1), S2.1 (S), S2.2 (S1), S3.3, S3.4 (P1), U1.8 (GND), U1.22 (GND); also elsewhere on the board
LED-DATA: U1.15 (PB1(OC1A)); also elsewhere on the board
LOAD: U1.25 (PC2(ADC2)); also elsewhere on the board
unnamed: C2.1, R1.1, S3.1 (S), S3.2 (S1), U1.1 (PC6(/RESET))
unnamed: S0.3, S0.4 (P1), U1.2 (PD0(RXD))
unnamed: C5.1, Q1.2, U1.9 (PB6(XTAL1/TOSC1))
unnamed: S1.3, S1.4 (P1), U1.3 (PD1(TXD))
unnamed: S2.3, S2.4 (P1), U1.4 (PD2(INT0))
unnamed: C6.1, Q1.1, U1.10 (PB7(XTAL2/TOSC2))
unnamed: LED1.A, R2.1
PB0: JPB.2, R2.2, U1.14 (PB0(ICP))
PB2: JPB.4, U1.16 (PB2(SS/OC1B))
PB3: JPB.5, U1.17 (PB3(MOSI/OC2))
PB4: JPB.6, U1.18 (PB4(MISO))
PB5: JPB.7, U1.19 (PB5(SCK))
PC4: JPA.2, U1.27 (PC4(ADC4/SDA))
PC5: JPA.7, U1.28 (PC5(ADC5/SCL))
PD3: JPD.2, U1.5 (PD3(INT1))
PD4: JPD.3, U1.6 (PD4(XCK/T0))
PD5: JPD.4, U1.11 (PD5(T1))
PD6: JPD.5, U1.12 (PD6(AIN0))
PD7: JPD.6, U1.13 (PD7(AIN1))
VCC: C3.1, C4.1, JPA.1, JPA.6, JPB.1, JPD.1, R1.2, U1.7 (VCC), U1.20 (AVCC); also elsewhere on the board

Board: 2 copper layers, 179.1 x 107.9 mm, 69 parts (6 on the bottom side), 154 nets.

Other parts of the board:
U$1, U$2, U$3, U$4: 3,0

## EAGLE design crystalis.brd

Parts:
20K: adj; 0207/5V
C1: 10uF/25V; E2,5-6
C2, C3, C7, C8: 0.1uF; C025-025X050
C4: 220/6VuF; E2,5-6
C5, C6: 6pF; C025-024X044
C9, C11: 100nf; C050-030X075
C10: 1if; C025-030X050
CL1, CL2, CL3, CL4: 100nf; C1206
D1: 1N4001; DO41-10
D2: 1N5817; DO41-10
DIS2: IV18
GROUND: SHORT; M1206
IC3: 7805T; TO220H
ISP1: AVRISP-6; AVRISP
J1: 2.1MMJACK; PJ-102A
JP1: PINHD-1X6; 1X06
JP2: big; MA12-2
JP3: small; MA12-2
L1, L2, L3, L4: WS2812B
LIGHT: 40-XX; B3F-40XX
MODE: 40-XX; B3F-40XX
NEXT: 40-XX; B3F-40XX
Q1: XTAL/S; QS
R1: 4.7K; 0309/12
R2: adj; 0207/5V
RESET: 10-XX; B3F-10XX
SP1: SPEAKER/PS12; PS12
TOGGLE: 40-XX; B3F-40XX
TUBE: WS2812B
U1: ATMEGA328P_PDIP; DIL28-3
U$1: LM4871; SO08
U$2: MAX6921; PLCC-S28

Connections:
1'GRID: DIS2.15 (1), JP3.12
2'GRID: DIS2.22 (2), JP3.19
3'GRID: DIS2.16 (3), JP3.13
4'GRID: DIS2.21 (4), JP3.18
5'GRID: DIS2.17 (5), JP3.14
6'GRID: DIS2.20 (6), JP3.17
7'GRID: DIS2.19 (7), JP3.16
8'GRID: DIS2.18 (8), JP3.15
9'GRID: DIS2.14 (9), JP3.11
'1'GRID: JP2.12, U$2.6 (OUT16)
'2'GRID: JP2.19, U$2.7 (OUT15)
'3'GRID: JP2.13, U$2.8 (OUT14)
'4'GRID: JP2.18, U$2.9 (OUT13)
'5'GRID: JP2.14, U$2.10 (OUT12)
'6'GRID: JP2.17, U$2.11 (OUT11)
'7'GRID: JP2.16, U$2.12 (OUT10)
'8'GRID: JP2.15, U$2.17 (OUT9)
'9'GRID: JP2.11, U$2.18 (OUT8)
'A'SEG: JP2.9, U$2.26 (OUT0)
'B'SEG: JP2.7, U$2.25 (OUT1)
'C'SEG: JP2.4, U$2.24 (OUT2)
'D'SEG: JP2.3, U$2.23 (OUT3)
'DP: JP2.2, U$2.19 (OUT7)
'E'SEG: JP2.5, U$2.22 (OUT4)
'F'SEG: JP2.8, U$2.21 (OUT5)
'FIL+: JP2.1, R2.2
'FIL-: JP2.10, U$1.5 (VO1)
'G'SEG: JP2.6, U$2.20 (OUT6)
+24V: C1.+, C8.1, C9.1, D1.C, IC3.1 (VI), U$2.1 (VBB)
A0: JP1.3, U1.12 (PD6(AIN0))
A1: JP1.2, U1.13 (PD7(AIN1))
A'SEG: DIS2.12 (A), JP3.9
AGND: C9.2, C11.2, CL1.2, CL2.2, CL3.2, CL4.2, GROUND.1, JP2.23, L1.3-GND (GND), L2.3-GND (GND), L3.3-GND (GND), L4.3-GND (GND)
AGND': JP3.23, TUBE.3-GND (GND)
B'SEG: DIS2.10 (B), JP3.7
BLANK: U1.26 (PC3(ADC3)), U$2.13 (BLANK)
C'SEG: DIS2.4 (C), JP3.4
CLK: U1.24 (PC1(ADC1)), U$2.15 (CLK)
D'SEG': DIS2.3 (D), JP3.3
DATA: U1.23 (PC0(ADC0)), U$2.27 (DIN)
DP: DIS2.2 (H), JP3.2
E'SEG: DIS2.5 (E), JP3.5
F'SEG: DIS2.11 (F), JP3.8
FIL+: DIS2.13 (VBIAS), JP3.1
FIL-: DIS2.1 (GND), JP3.10
G'SEG: DIS2.9 (G), JP3.6
GND: C1.-, C2.2, C3.2, C4.-, C5.2, C6.2, C7.2, C8.2, C10.1, GROUND.2, IC3.2 (GND), ISP1.6 (GND), J1.RING, J1.RING_SW, JP1.1, LIGHT.1 (S), LIGHT.2 (S1), MODE.1 (S), MODE.2 (S1), NEXT.1 (S), NEXT.2 (S1), RESET.3, RESET.4 (P1), TOGGLE.1 (S), TOGGLE.2 (S1), U1.8 (GND), U1.22 (GND), U$1.1 (SHUTDOWN), U$1.7 (GND), U$2.14 (GND)
LED-DATA: L1.4-DIN (DIN), U1.11 (PD5(T1))
LED-IN: JP3.22, TUBE.4-DIN (DIN)
LED-OUT: JP2.22, L4.2-DOUT (DOUT)
LOAD: U1.25 (PC2(ADC2)), U$2.16 (LOAD)
MISO: ISP1.1 (MISO), U1.18 (PB4(MISO))
MOSI: ISP1.4 (MOSI), U1.17 (PB3(MOSI/OC2))
unnamed: MODE.3, MODE.4 (P1), U1.5 (PD3(INT1))
unnamed: D1.A, J1.TIP
unnamed: 20K.2, U$1.4 (-IN)
unnamed: R2.1, U$1.8 (VO2)
unnamed: C10.2, U$1.2 (BYPASS), U$1.3 (+IN)
unnamed: LIGHT.3, LIGHT.4 (P1), U1.2 (PD0(RXD))
unnamed: C5.1, Q1.2, U1.9 (PB6(XTAL1/TOSC1))
unnamed: NEXT.3, NEXT.4 (P1), U1.3 (PD1(TXD))
unnamed: TOGGLE.3, TOGGLE.4 (P1), U1.4 (PD2(INT0))
unnamed: SP1.P$1 (+), U1.15 (PB1(OC1A))
unnamed: C6.1, Q1.1, U1.10 (PB7(XTAL2/TOSC2))
unnamed: SP1.P$2 (-), U1.16 (PB2(SS/OC1B))
unnamed: D2.A, IC3.3 (VO)
unnamed: L1.2-DOUT (DOUT), L2.4-DIN (DIN)
unnamed: L2.2-DOUT (DOUT), L3.4-DIN (DIN)
unnamed: L3.2-DOUT (DOUT), L4.4-DIN (DIN)
OSC: 20K.1, U1.6 (PD4(XCK/T0))
RESET: C2.1, ISP1.5 (RST), R1.1, RESET.1 (S), RESET.2 (S1), U1.1 (PC6(/RESET))
SCK: ISP1.3 (SCK), U1.19 (PB5(SCK))
SCL: JP1.4, U1.28 (PC5(ADC5/SCL))
SDA: JP1.5, U1.27 (PC4(ADC4/SDA))
VCC: C3.1, C4.+, C7.1, C11.1, CL1.1, CL2.1, CL3.1, CL4.1, D2.C, ISP1.2 (VCC), JP1.6, JP2.24, L1.1-VDD (VDD), L2.1-VDD (VDD), L3.1-VDD (VDD), L4.1-VDD (VDD), R1.2, U1.7 (VCC), U1.20 (AVCC), U$1.6 (VDD), U$2.28 (VCC)
VCC': JP3.24, TUBE.1-VDD (VDD)

Notes on the sheet:
5V Power Supply
AC filament
Atmel 328 system
水晶剑

Board: 2 copper layers, 164.5 x 50.5 mm, 47 parts (10 on the bottom side), 76 nets.

Other parts of the board:
U$3, U$4, U$5, U$6: 3,0

## Commit log

2018-04-03 Backlink to CADLAB.io has been added.
2021-05-15 Added library file and some data sheet

Notices in the files:
parts and their libraries:
SparkFun-DigitalIC: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
